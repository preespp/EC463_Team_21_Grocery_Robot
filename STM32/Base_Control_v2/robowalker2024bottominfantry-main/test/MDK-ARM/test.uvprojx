# Keil uVision project test.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: DEBUG,USE_HAL_DRIVER,STM32F427xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --cpp11
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User_File;../User_Third_Party/eigen-3.3.9
  asm define: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/Library/DSP Library/DSP Library
    C:/Keil_v5/ARM/PACK/Keil/STM32F4xx_DFP/2.8.0/Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group User
    ../User_File/1_Middleware/1_Driver/BSP/: drv_djiboarda.cpp
    ../User_File/1_Middleware/1_Driver/Math/: drv_math.cpp
    ../User_File/1_Middleware/1_Driver/CAN/: drv_can.cpp
    ../User_File/1_Middleware/1_Driver/UART/: drv_uart.cpp
    ../User_File/1_Middleware/1_Driver/TIM/: drv_tim.cpp
    ../User_File/1_Middleware/2_Algorithm/PID/: alg_pid.cpp
    ../User_File/2_Device/Motor/Motor_DJI/: dvc_motor_dji.cpp
    ../User_File/2_Device/Serialplot/: dvc_serialplot.cpp
    ../User_File/3_Chariot/1_Module/Chassis/: crt_chassis.cpp
    ../User_File/1_Middleware/2_Algorithm/Slope/: alg_slope.cpp
    ../User_File/2_Device/PC/: dvc_pc.cpp
    ../User_File/4_Interaction/: ita_robot.cpp
    ../User_File/5_Task/: tsk_config_and_callback.cpp
  group AutoAdded/CMake
    ../Core/Src/: iwdg.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../USB_DEVICE/Target/: usbd_conf.c
    ../User_File/1_Middleware/1_Driver/ADC/: drv_adc.cpp
    ../User_File/1_Middleware/1_Driver/SPI/: drv_spi.cpp
    ../User_File/1_Middleware/1_Driver/WDG/: drv_wdg.cpp
    ../User_File/1_Middleware/2_Algorithm/Filter/: alg_filter.cpp
    ../User_File/1_Middleware/2_Algorithm/FSM/: alg_fsm.cpp
    ../User_File/1_Middleware/2_Algorithm/Queue/: alg_queue.cpp
    ../User_File/1_Middleware/2_Algorithm/Timer/: alg_timer.cpp
software components: CMSIS:CORE 4.3.0
